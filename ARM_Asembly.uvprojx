# Keil uVision project ARM_Asembly.uvprojx, settings and files
target Cotex-M3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ARM_Asembly
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\RTOS;.\Hardware;.\RTE\Device\STM32F103C8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/: main.c My_RTOS.c My_RTOS.h
  group RTOS
    ./RTOS/: sched.c sched.h task.c task.h semaphore.c semaphore.h task_switch.s queue.c queue.h timers.c timers.h event_groups.c event_groups.h heap.c heap.h
  group Hardware
    ./Hardware/: Led.c Led.h Usart.c Usart.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
